# Keil uVision project at32_Pro.uvprojx, settings and files
target at32_pro (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: AT32F405KCU7-4 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.0.8
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32_Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,USB_OTG_HS
  c include: .\Hardware;.\Library\inc;.\Library\src;.\start_up\clock_support;.\start_up\core_support;.\start_up\int_support;.\start_up\start_support;.\User;.\app;.\DeepCool_driver;.\usbd_driver;.\usbd_class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group app
    ./app/: main.c
    ./start_up/clock_support/: at32f402_405_clock.c
    ./start_up/int_support/: at32f402_405_int.c
  group Library
    ./Library/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group start_up
    ./start_up/start_support/: startup_at32f402_405.s system_at32f402_405.c
  group Readme
    ./: readme.txt
  group DeepCool_driver
    ./DeepCool_driver/: at32_spi.c at32_timer.c delay.c i2c_application.c soft_timer.c at32_mykeyboard.c at32_usb.c at32_oled.c at32_encoder.c at32_iic.c at32_ws2812_rgb.c myflash.c myflash_store.c update.c at32_rgb_animation.c
  group usbd_driver
    ./usbd_driver/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ./usbd_class/: keyboard_class.c keyboard_desc.c
